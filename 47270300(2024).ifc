Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 50356248-56fd-404e-bfe4-5503dd407272, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 47270300(2024).ifc
Time: 2025-01-29T23:44:52
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcFlowController: 47270300(2024):47270300 Overhead shower, d 300 mm, 47270300(2024):47270300 Overhead shower, d 300 mm:373002
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - General - Author: BIMStone; BIMObjectName: 47270300(2024); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1112; ETIM Class Number: EC011383 Shower head; Noise Class: I (ISO 3822); UNSPSC Class Number: 30181801 Shower head; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/47270300; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/196334_47270300_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Backflow Prevention EN1717: EB; Connection: External thread;Cover plate(s); Connection Size: G1/2; Flow Rate At 300kPa With Flow Reducers: 0.2 dm3/s; Installation Type: Ceiling mounted; Max. Hot Water Supply: 65 C; Mounting Holes: 1 hole; Over Head Shower Size: Ø 300 mm; Shower Parts: Overhead shower;Rotatable ball joint connection;Anti limescale technology (easy to clean); Shower Spray: Refreshing - Strong water stream, activates and refreshes body; Shower Spray Number: 1 spray function; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Construction - Type: 0 mm
Type - Dimensions - NominalDepth: 300 mm; NominalHeight: 264.7 mm; NominalWidth: 299.8 mm
Type - Identity Data - 3D View: https://static.hansa.com/3D/47270300; Catalog Drawing URL: http://static.hansa.com/catdrw/47270300; Category B2C: Shower solutions; Color variants: 4727030033;4727030080;4727030081; Dimension Drawing URL: http://static.hansa.com/dimdrw/47270300; FDV Document URL: http://www.hansa.com/datasheet/47270300/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/47270300; Group: Overhead shower; Installation and Maintenance Guide URL: http://static.hansa.com/manual/47270300; Interactive AR View URL: https://static.hansa.com/AR/47270300; Long Marketing: HANSAAURELIA. A Harmony of Simplicity and Elegance. AURELIA draws design inspiration from the exquisite elements found in wild nature. The gentle curve of a tiny waterdrop serves as the blueprint for our hand and head showers, completing the design with elegance. Stand beneath the cascading water to experience a symphony of sensations, as clever design ensures efficient water distribution, embracing the complete body in refreshing and rejuvenating comfort. Elevate your daily ritual with HANSAAURELIA, where every drop becomes a celebration of inherent beauty. 300mm Head shower Sealing installation ELEVATING YOUR MOMENTS; Manufacturer: HANSA; Market: International;Poland;Germany;Austria;Switzerland;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.hansa.com/47270300; Model: 47270300 Overhead shower, d 300 mm; Name_en: 47270300 Overhead shower, d 300 mm; OmniClass Number: 23.45.55.00; Product Code: 47270300; Product Family: HANSAAURELIA; Product Image URL: http://static.hansa.com/image/47270300; Product URL: http://static.hansa.com/47270300; Technical DataSheet URL: http://www.hansa.com/datasheet/47270300/en; Type Name: 47270300 Overhead shower, d 300 mm; Warranty Information URL: http://warranty.hansa.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 47270300(2024); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 47270300; Name: 47270300 Overhead shower, d 300 mm; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 47270300; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 47270300 Overhead shower, d 300 mm
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 47270300 Overhead shower, d 300 mm; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Area: 0.248651 m2; Volume: 0.0237994 m3
Identity Data - Mark: 11
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 47270300(2024); Family and Type: 47270300(2024): 47270300 Overhead shower, d 300 mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 47270300 Overhead shower, d 300 mm; Type Id: 372980; WarrantyStartDate: n/a
